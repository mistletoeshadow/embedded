# Keil uVision project LWIP无操作系统移植.uvprojx, settings and files
target LWIP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\LWIP\lwip-1.4.1\lwip-1.4.1\src\api;..\MALLOC;..\LWIP\lwip-1.4.1\lwip-1.4.1\src\core;..\LWIP\lwip-1.4.1\lwip-1.4.1\src\include;..\LWIP\lwip-1.4.1\lwip-1.4.1\src\netif;..\LWIP\lwip-1.4.1\lwip-1.4.1\src\core\ipv4;..\LWIP\lwip-1.4.1\lwip-1.4.1\src\include\ipv4;..\LWIP\lwip-1.4.1\lwip-1.4.1\src\include\netif;..\HARDWARE\ENC28J60;..\HARDWARE\KEY;..\HARDWARE\SPI;..\HARDWARE\SRAM;..\HARDWARE\TIMER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/ENC28J60/: enc28j60.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/TIMER/: timer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c
  group README
    ../: README.TXT
  group MALLOC
    ../MALLOC/: malloc.c
  group LWIP-NETIF
    ../LWIP/lwip-1.4.1/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP-CORE
    ../LWIP/lwip-1.4.1/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../LWIP/lwip-1.4.1/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LWIP-API
    ../LWIP/lwip-1.4.1/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
